# KOMPAS-3D part (ZARD 080.025.10.P.m3d)

Model tree:
1. Булева операция:1
2. Булева операция:2

Texts:
  ЗАРД 080.025.10-ХХ.Р